# CATIA V5 part "tepsi.CATPart"
Saved by CATIA V5R29
Part number: tepsi
Revision: HERHANG?
Definition: B??MEYEN
Nomenclature: tepsi
Source: Unknown
Stored file links:
  C:\가치같이\SmartFactory_Freeze dryer\tepsi.CATPart
  HeatDryer.CATPart

## Design history (mm, degrees; sets first, then bodies; in a sketch O, H, V are its origin and axes)
Body1 "Y?seklik-Ekstr?yon9" (main body)
Body2
# CATIA V5 part "HPTBS6-SET_b..CATPart"
Saved by CATIA V5R29
Part number: HPTBS6-SET_b.
Definition: Cadenas PARTsolutions
Source: Unknown
Description: Sheet Metal Brackets - For HFS6 Series - Bent Type
Stored file links:
  C:\Users\Administrator\Desktop\프로젝트\Boxfold\TapeCutter\HPTBS6-SET_b..CATPart

## Design history (mm, degrees; sets first, then bodies; in a sketch O, H, V are its origin and axes)
Body1 "HPTBS6-SET_b." (main body)